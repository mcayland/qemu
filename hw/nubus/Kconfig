## hw/nubus/Kconfig
```kconfig
config NUBUS
    bool

config NUBUS_VGA
    bool
    depends on NUBUS
    select VGA
```
